DEPENDS_append = " mali-blobs"
RDEPENDS_${PN} += " mali-blobs"
